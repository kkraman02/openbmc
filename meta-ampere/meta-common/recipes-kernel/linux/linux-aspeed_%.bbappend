SRC_URI = " \
           git://github.com/ampere-openbmc/linux;protocol=https;branch=ampere \
           file://defconfig \
          "

SRCREV="727eb2baddc5c70f45d997481ab9fc8c045043f9"
