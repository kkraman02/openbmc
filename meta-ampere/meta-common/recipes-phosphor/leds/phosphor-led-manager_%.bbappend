SYSTEMD_SERVICE:${PN}-faultmonitor:remove = "obmc-fru-fault-monitor.service"
